Commit message: added a new velocity frame transformation and test

File: tests/test_data/test_a1.urdf (robot description, URDF)
Before this commit: robot a1, 23 links, 22 joints
Joints:
- joint imu_joint: origin xyz=0 0 0 rpy=0 0 0 -> xyz=0.1 0.03 0.02 rpy=0.1 0.5 0.9
